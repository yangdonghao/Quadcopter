# Keil uVision project Quadcopter.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Quadcopter
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,MPU9150,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,EMPL_TARGET_STM32F4
  c misc: --C99 --wchar32
  c include: .\RTE\Device\eMPL\driver\STM32F4;.\RTE\Device\eMPL\driver\eMPL;.\RTE\Device\eMPL\driver\include;.\RTE\Device\eMPL\eMPL-hal;.\RTE\Device\eMPL\mllite;.\RTE\Device\eMPL\mpl
  asm include: .\RTE\Device\STM32F407VGTx\STCubeGenerated\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/eMD
    ./RTE/Device/eMPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./RTE/Device/eMPL/driver/STM32F4/: log_stm32.c stm32f4xx_empl_drv.c
    ./RTE/Device/eMPL/eMPL-hal/: eMPL_outputs.c
    ./RTE/Device/eMPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./RTE/Device/eMPL/mpl/: libmpllib.a
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group Application/User
    ./RTE/Device/eMPL/driver/STM32F4/: mpu.c
software components: CMSIS:CORE 5.0.0, Board Support:LED 2.0.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:Startup 2.5.0
